PACKAGECONFIG:append = "gl gles2 eglfs directfb kms widgets journald"
